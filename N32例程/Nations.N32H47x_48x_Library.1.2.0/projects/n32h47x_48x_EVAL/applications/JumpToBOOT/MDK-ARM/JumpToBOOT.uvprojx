# Keil uVision project JumpToBOOT.uvprojx, settings and files
target N32G033 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.1.2.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: JumpToBOOT +hex
  AfterMake: fromelf --bin --output=.\bin\JumpToBOOT.bin .\Objects\JumpToBOOT.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32H487, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\bsp\inc;..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group STARTUP
    ../../../../../firmware/CMSIS/device/startup/: startup_n32h47x_48x.s
  group CMSIS
    ../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_flash.c n32h47x_48x_gpio.c n32h47x_48x_iwdg.c n32h47x_48x_rcc.c n32h47x_48x_usart.c
  group BSP
    ../../../bsp/src/: log.c
  group USER
    ../src/: main.c
  group DOC
    ../: readme.txt
