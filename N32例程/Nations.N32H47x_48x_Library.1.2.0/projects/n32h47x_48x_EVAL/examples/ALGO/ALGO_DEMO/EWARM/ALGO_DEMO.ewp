# IAR project ALGO_DEMO.ewp, settings and files
configuration N32H47X (ARM, debug)
  General.OGChipSelectEditMenu: N32H474QE Nations N32H474QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: N32H474; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc; ..\..\..\..\bsp\inc; ..\inc; ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ALGO_DEMO.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\lib\n32h47x_48x_aes.a; ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\lib\n32h47x_48x_common.a; ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\lib\n32h47x_48x_des.a; ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\lib\n32h47x_48x_hash.a; ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\lib\n32h47x_48x_rng.a; ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\lib\n32h47x_48x_sm4.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration N32H480 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H480ZE Nations N32H480ZE
  General.FPU2: 4
  ICCARM.CCDefines: N32H480; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc; ..\inc; ..\..\..\..\bsp\inc
configuration N32H48X (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H488ZE Nations N32H488ZE
  ICCARM.CCDefines: N32H488; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\bsp\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32h47x_48x_algo_lib\inc; ..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc; ..\inc
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_exti.c n32h47x_48x_gpio.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_usart.c
  group LOG
    ../../../../bsp/src/: delay.c log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h47x_48x_EWARM.s
  group USER
    ../src/: algo_demo.c main.c n32h47x_48x_it.c
