# IAR project FDCAN_Classic.ewp, settings and files
configuration N32H47X (ARM, debug)
  General.OGChipSelectEditMenu: N32H474QE Nations N32H474QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32H474; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32h47x_48x_std_periph_driver/inc; ../../../../bsp/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FDCAN_Classic.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration N32H480 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H480ZE Nations N32H480ZE
  ICCARM.CCDefines: N32H480; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
configuration N32H48X (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H488ZE Nations N32H488ZE
  ICCARM.CCDefines: N32H488; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
  group BSP
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group DOC
    ../: readme.txt
  group FWLIB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_fdcan.c n32h47x_48x_gpio.c n32h47x_48x_rcc.c n32h47x_48x_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h47x_48x_EWARM.s
  group USER
    ../src/: main.c n32h47x_48x_it.c
