# Keil uVision project mqtt_client.uvprojx, settings and files
target N32H48X (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H488ZE Nationstech
  pack: Nationstech.N32H48x_DFP.1.2.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mqtt_client +hex
  AfterMake: fromelf --bin --output=.\bin\mqtt_client.bin .\Objects\mqtt_client.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H488, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc;..\..\..\..\..\..\middlewares\lwip-2.2.0\src\include;..\..\..\..\..\..\middlewares\lwip-2.2.0\src\include\compat;..\..\..\..\..\..\middlewares\lwip-2.2.0\src\include\lwip;..\..\..\..\..\..\middlewares\lwip-2.2.0\src\include\lwip\apps;..\..\..\..\..\..\middlewares\lwip-2.2.0\src\include\lwip\priv;..\..\..\..\..\..\middlewares\lwip-2.2.0\src\include\lwip\prot;..\..\..\..\..\..\middlewares\lwip-2.2.0\src\include\netif;..\bsp;..\bsp\arch;..\..\..\..\..\..\middlewares\FreeRTOSv202212.01\Source\include;..\..\..\..\..\..\middlewares\FreeRTOSv202212.01\Source\portable\RVDS\ARM_CM4F;..\mqtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h47x_48x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_eth.c n32h47x_48x_exti.c n32h47x_48x_flash.c n32h47x_48x_gpio.c n32h47x_48x_rcc.c n32h47x_48x_usart.c
  group LwIP\src\api
    ../../../../../../middlewares/lwip-2.2.0/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP\src\core
    ../../../../../../middlewares/lwip-2.2.0/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group LwIP\src\core\ipv4
    ../../../../../../middlewares/lwip-2.2.0/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP\src\netif
    ../../../../../../middlewares/lwip-2.2.0/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group FreeRTOS\Source
    ../../../../../../middlewares/FreeRTOSv202212.01/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS\Source\portable
    ../../../../../../middlewares/FreeRTOSv202212.01/Source/portable/MemMang/: heap_4.c
    ../../../../../../middlewares/FreeRTOSv202212.01/Source/portable/RVDS/ARM_CM4F/: port.c
  group ETH\bsp
    ../bsp/: bsp_eth.c ethernetif.c sys_arch.c
  group MQTT
    ../mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c transport.c
  group cJSON
    ../src/: cJSON.c
    ../bsp/: bsp_cjson.c
  group USER
    ../src/: main.c mqtt_client.c n32h47x_48x_it.c dht11.c
  group BSP
    ../../../../bsp/src/: log.c delay.c
  group DOC
    ../: readme.txt
