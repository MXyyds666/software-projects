# IAR project mqtt_client.ewp, settings and files
configuration N32H48X (ARM, debug)
  General.OGChipSelectEditMenu: N32H488ZE Nations N32H488ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32H488; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa130
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc; ..\..\..\..\bsp\inc; ..\..\..\..\..\..\middlewares\lwip-2.2.0\src\include; ..\..\..\..\..\..\middlewares\lwip-2.2.0\src\include\lwip; ..\..\..\..\..\..\middlewares\lwip-2.2.0\src\include\lwip\apps; ..\..\..\..\..\..\middlewares\lwip-2.2.0\src\include\lwip\priv; ..\..\..\..\..\..\middlewares\lwip-2.2.0\src\include\lwip\prot; ..\..\..\..\..\..\middlewares\lwip-2.2.0\src\include\netif; ..\bsp; ..\bsp\arch; ..\..\..\..\..\..\middlewares\FreeRTOSv202212.01\Source\include; ..\..\..\..\..\..\middlewares\FreeRTOSv202212.01\Source\portable\IAR\ARM_CM4F; ..\mqtt
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: mqtt_client.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: mqtt_client.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../../../bsp/src/: delay.c log.c
  group cJSON
    ../bsp/: bsp_cjson.c
    ../src/: cJSON.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group DOC
    ../: readme.txt
  group ETH\bsp
    ../bsp/: bsp_eth.c ethernetif.c sys_arch.c
  group FreeRTOS\Source
    ../../../../../../middlewares/FreeRTOSv202212.01/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS\Source\portable
    ../../../../../../middlewares/FreeRTOSv202212.01/Source/portable/MemMang/: heap_4.c
    ../../../../../../middlewares/FreeRTOSv202212.01/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_eth.c n32h47x_48x_exti.c n32h47x_48x_flash.c n32h47x_48x_gpio.c n32h47x_48x_rcc.c n32h47x_48x_usart.c
  group LwIP\src\api
    ../../../../../../middlewares/lwip-2.2.0/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP\src\core
    ../../../../../../middlewares/lwip-2.2.0/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group LwIP\src\core\ipv4
    ../../../../../../middlewares/lwip-2.2.0/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP\src\netif
    ../../../../../../middlewares/lwip-2.2.0/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group MQTT
    ../mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c transport.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h47x_48x_EWARM.s
  group USER
    ../src/: dht11.c main.c mqtt_client.c n32h47x_48x_it.c
