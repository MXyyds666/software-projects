<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\http_control_led.ewp</path>
  </project>
  <batchBuild/>
</workspace>
