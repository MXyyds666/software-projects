# Keil uVision project 485_Mastre.uvprojx, settings and files
target N32H48x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H488ZE Nationstech
  pack: Nationstech.N32H48x_DFP.1.2.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 485_Mastre +hex
  AfterMake: fromelf --bin --output=.\bin\485_Mastre.bin .\Objects\485_Mastre.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H488, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\bsp\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32h47x_48x.s
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_dma.c n32h47x_48x_flash.c n32h47x_48x_gpio.c n32h47x_48x_usart.c n32h47x_48x_rcc.c
  group USER
    ../src/: main.c n32h47x_48x_it.c
  group BSP
    ../../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
