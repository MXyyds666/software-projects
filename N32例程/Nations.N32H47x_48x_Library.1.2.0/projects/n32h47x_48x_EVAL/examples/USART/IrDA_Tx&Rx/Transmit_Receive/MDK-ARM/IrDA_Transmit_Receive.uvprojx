# Keil uVision project IrDA_Transmit_Receive.uvprojx, settings and files
target N32H47x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H474QE Nationstech
  pack: Nationstech.N32H47x_DFP.1.2.0
  cpu: IRAM(0x20000000,0x31000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IrDA_Transmit_Receive +hex
  AfterMake: fromelf --bin --output=.\bin\IrDA_Transmit_Receive.bin .\Objects\IrDA_Transmit_Receive.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H474, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\bsp\inc;..\..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32h47x_48x.s
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_dma.c n32h47x_48x_flash.c n32h47x_48x_gpio.c n32h47x_48x_usart.c n32h47x_48x_rcc.c n32h47x_48x_tim.c
  group USER
    ../src/: main.c n32h47x_48x_it.c bsp_Tim_38K.c
  group BSP
    ../../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
target N32H480 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H480ZE Nationstech
  pack: Nationstech.N32H48x_DFP.1.2.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IrDA_Transmit_Receive +hex
  AfterMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H480, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
target N32H48x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H488ZE Nationstech
  pack: Nationstech.N32H48x_DFP.1.2.0
  cpu: as above
  output: IrDA_Transmit_Receive +hex
  AfterMake: as above
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H488, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
