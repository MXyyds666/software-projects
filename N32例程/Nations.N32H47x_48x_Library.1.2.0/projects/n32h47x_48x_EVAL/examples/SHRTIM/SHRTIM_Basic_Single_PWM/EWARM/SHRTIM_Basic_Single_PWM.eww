<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SHRTIM_Basic_Single_PWM.ewp</path>
  </project>
  <batchBuild/>
</workspace>
