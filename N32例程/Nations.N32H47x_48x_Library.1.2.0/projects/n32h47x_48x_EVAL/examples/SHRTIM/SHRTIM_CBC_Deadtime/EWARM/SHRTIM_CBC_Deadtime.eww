<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SHRTIM_CBC_Deadtime.ewp</path>
  </project>
  <batchBuild/>
</workspace>
