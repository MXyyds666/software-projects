# Keil uVision project Tamper.uvprojx, settings and files
target N32H47X (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H474QE Nationstech
  pack: Nationstech.N32H47x_DFP.1.2.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Tamper +hex
  AfterMake: fromelf --bin --output=.\bin\Tamper.bin .\Objects\Tamper.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32H474, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h47x_48x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_rcc.c n32h47x_48x_pwr.c n32h47x_48x_usart.c n32h47x_48x_gpio.c n32h47x_48x_rtc.c n32h47x_48x_exti.c n32h47x_48x_dbg.c
  group USER
    ../src/: main.c n32h47x_48x_it.c User_RTC_Config.c
  group DOC
    ../: readme.txt
  group BSP
    ../../../../bsp/src/: log.c delay.c
target N32H480 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H480ZE Nationstech
  pack: Nationstech.N32H48x_DFP.1.2.0
  cpu: as above
  output: Tamper +hex
  AfterMake: fromelf --bin --output=.\bin\Tamper.bin .\Objects\Tamper.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32H480, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
target N32H48X (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H488ZE Nationstech
  pack: Nationstech.N32H48x_DFP.1.2.0
  cpu: as above
  output: Tamper +hex
  AfterMake: fromelf --bin --output=.\bin\Tamper.bin .\Objects\Tamper.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32H488, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
