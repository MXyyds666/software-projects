# IAR project PMBUS_Master_Int.ewp, settings and files
configuration N32H47X (ARM, debug)
  General.OGChipSelectEditMenu: N32H474QE Nations N32H474QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32H474; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32h47x_48x_std_periph_driver/inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PMBUS_Master_Int.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration N32H480 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H480ZE Nations N32H480ZE
  ICCARM.CCDefines: N32H480; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
configuration N32H48X (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: N32H488ZE Nations N32H488ZE
  ICCARM.CCDefines: N32H488; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_crc.c n32h47x_48x_dma.c n32h47x_48x_exti.c n32h47x_48x_gpio.c n32h47x_48x_i2c.c n32h47x_48x_rcc.c n32h47x_48x_spi.c n32h47x_48x_usart.c
  group LOG
    ../../../../bsp/src/: delay.c log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h47x_48x_EWARM.s
  group USER
    ../src/: I2CMaster.c main.c n32h47x_48x_it.c PMBusMaster.c
