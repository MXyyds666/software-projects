<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PMBus_Slave_Int.ewp</path>
    </project>
    <batchBuild />
</workspace>
