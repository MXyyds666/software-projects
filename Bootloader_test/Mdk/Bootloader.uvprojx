# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F456CEU7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: can
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F456CEU7,USE_STDPERIPH_DRIVER,AT_START_F456_V1
  c include: ..\User\inc;..\lib\cmsis\cm4\device_support;..\lib\cmsis\cm4\core_support;..\lib\drivers\inc;..\Bsp;..\Modules;..\User\bootloader
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000004 size 0x24000
  group Cmsis
    ../lib/cmsis/cm4/device_support/startup/mdk/: startup_at32f45x.s
    ../lib/cmsis/cm4/device_support/: system_at32f45x.c
  group User
    ../User/src/: main.c at32f45x_int.c at32f45x_clock.c
  group Lib
    ../lib/drivers/src/: at32f45x_acc.c at32f45x_adc.c at32f45x_aes.c at32f45x_can.c at32f45x_crc.c at32f45x_crm.c at32f45x_dac.c at32f45x_debug.c at32f45x_dma.c at32f45x_emac.c at32f45x_ertc.c at32f45x_exint.c at32f45x_flash.c at32f45x_gpio.c at32f45x_i2c.c at32f45x_misc.c at32f45x_pwc.c at32f45x_qspi.c at32f45x_scfg.c at32f45x_sdio.c at32f45x_spi.c at32f45x_tmr.c at32f45x_trng.c at32f45x_usart.c at32f45x_usb.c at32f45x_wdt.c at32f45x_wwdt.c at32f45x_xmc.c
  group Bsp
    ../Bsp/: at32f45x_board.c bsp_tim.c
  group Modules
    ../Bsp/: bsp_can.c
  group Bootloader
    ../User/bootloader/: bl_can.c Parse_ComData.c variable.c IAP.c Flash.c System_Config.c Universal_Init.c
